**************************************************************
*  Electronic circuit simulation file generated by gSpiceUI  *
*             Version 0.9.98 Alpha (14/10/2009)              *
**************************************************************

* Include Directives
.include '65nm_bulk.pm' MOS

* Component Definitions
C1 OUT 0 0.5fF
M1 X IN V1 V1 PMOS W=150n L=65n
M2 X IN 0 0 NMOS W=100n L=65n
M3 Y X V2 V2 PMOS W=150n L=65n
M4 Y X 0 0 NMOS W=100n L=65n
M5 OUT Y V3 V3 PMOS W=150n L=65n
M6 OUT Y 0 0 NMOS W=100n L=65n
VDD1 V1 0 1.2V
VDD2 V2 0 0.8V
VDD3 V3 0 1.2V
Vin IN 0 PULSE(0 1.2 0 0.1ns 0.1ns 1ns 2.2ns)

* NG-Spice Simulation Commands
.OPTIONS NOPAGE NUMDGT=6 UNITS=Degress WIDTH=104
.PRINT TRAN V(OUT,0) V(OUT)
.TRAN 1.00n 10.00n 0.00n

.END
